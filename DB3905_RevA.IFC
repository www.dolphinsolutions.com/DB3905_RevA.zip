Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: DB3905_RevA.IFC
Time: 2020-06-01T08:35:08
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBuildingElementProxy: DB3001_BIM
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: DB3020
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: DB3030
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: DB3070
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: DB3100_BIM
In: Default Storey
Material: Steel
